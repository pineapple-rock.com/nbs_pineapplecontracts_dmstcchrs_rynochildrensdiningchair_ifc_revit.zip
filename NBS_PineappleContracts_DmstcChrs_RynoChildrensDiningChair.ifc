Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2019-08-15T13:46:10
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20171027_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Thu Aug 15 13:46:10 2019* Host: NCL-PI18* Database: C:\Users\McCannE\AppData\Local\Temp\{916FA15E-82B0-44F7-8C6B-8C649AC4B85B}\ifc* Database version: 5507* Database creation date: Thu Aug 15 13:46:09 2019* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Thu Aug 15 13:46:09 2019* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Thu Aug 15 13:46:09 2019* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcFurnishingElement: RynoChildrensDiningChair, NBS_PineappleContracts_DmstcChrs_RynoChildrensDiningChair:RynoChildrensDiningChair:8924
In: Level 1
Type - Classification: Pr_40_50_12_22 (Uniclass2015); Material: NBS_Concept
Type - BOS_General - Author: NBS; BIMObjectName: NBS_PineappleContracts_DomesticChairs_RynoChildrensDiningChair; ManufacturerName: Pineapple Contracts; ManufacturerURL: https://pineapplecontracts.com/; NBSCertification: www.nationalbimlibrary.com/cert/r4rpkmik; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: https://uk.pineapplecontracts.com/product/ryno-childrens-dining-chair/; Revision: n/a; Uniclass2015Title: Dining chairs; Uniclass2015Code: Pr_40_50_12_22; Uniclass2015Version: Products v1.14; Version: 1
Type - NBS_Data - SeatsAndBacksMaterial: n/a; SeatsAndBacksFinish: n/a; SeatsAndBacksColour: n/a; FramesMaterial: n/a; FramesFinish: n/a; FramesColour: n/a; Weight: 30 kg (as standard) 8kg (lightweight model)
Type - Pset_FurnitureTypeCommon - IsBuiltIn: no; MainColor: Availabe in 10 colours; NominalDepth: 525 mm; NominalHeight: 750 mm; NominalLength: 0 mm; Reference: n/a; Style: Childrens chair
Type - Pset_FurnitureTypeChair - HighestSeatingHeight: 380 mm; LowestSeatingHeight: 380 mm; SeatingHeight: 380 mm
Type - IFC - IfcExportAs: IfcFurnitureType; IfcExportType: CHAIR
Type - COBie - AccessibilityPerformance: n/a; AssetType: Movable; Category: Pr_40_50_12_22:Dining chairs; CodePerformance: To BS EN 16139:2013 - Level 2 (severe contract use), ANSI/BIFMA X5:5:2012; Color: Blaze orange, Vegas yellow, Icon purple, Epic blue, Lime, Thunder grey, Moonwalk grey, Cool green, Black, Granite; Constituents: n/a; Description: Children’s dining chair; DurationUnit: year; ExpectedLife: n/a; Features: Anti-microbial material provides protection throughout the product– not just on the surface, Upholstered seat and back pads option available (makes product not suitable for outdoor use), Ergonomically designed to Sizemark 4 posture requirements; Finish: Textured; Grade: n/a; Manufacturer: sales@pineapplecontracts.com; Material: Polyethylene; ModelNumber: ARYCD-30; ModelReference: Ryno Children's Dining Chair; Name: DomesticChairs_RynoChildren'sDiningChair_PineappleContracts; NominalWidth: 420 mm; ReplacementCost: n/a; Shape: n/a; Size: 750 x 420 x 525 mm; SustainabilityPerformance: 100% recycable; WarrantyDescription: Lifetime guarantee; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
